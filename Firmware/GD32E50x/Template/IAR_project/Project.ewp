# IAR project Project.ewp, settings and files
configuration GD32E50X_CL (ARM, debug)
  General.OGChipSelectEditMenu: GD32E507xE GD GD32E507xE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32E50X_CL; GD32E50X
  ICCARM.CCIncludePath2: ..; ..\..\Utilities; ..\..\Firmware\GD32E50x_standard_peripheral\Include; ..\..\Firmware\CMSIS\GD\GD32E50x\Include; ..\..\Firmware\CMSIS
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration GD32E50X_XD (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: GD32E503xE GD GD32E503xE
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32E50X_XD; GD32E50X
configuration GD32E50X_HD (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: GD32E503xE GD GD32E503xE
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32E50X_HD; GD32E50X
configuration GD32EPRT (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: GD32EPRTxD GD GD32EPRTxD
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32EPRT; GD32E50X
configuration GD32E508 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: GD32E508xE GD GD32E508xE
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32E508; GD32E50X
  group Application
    ../: gd32e50x_it.c main.c systick.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32E50x/Source/: system_gd32e50x.c
  group Doc
    ../: readme.txt
  group GD32E50x_EVAL
    ../../Utilities/: gd32e507z_eval.c
  group GD32E50x_Peripherals
    ../../Firmware/GD32E50x_standard_peripheral/Source/: gd32e50x_adc.c gd32e50x_bkp.c gd32e50x_can.c gd32e50x_cmp.c gd32e50x_crc.c gd32e50x_ctc.c gd32e50x_dac.c gd32e50x_dbg.c gd32e50x_dma.c gd32e50x_enet.c gd32e50x_exmc.c gd32e50x_exti.c gd32e50x_fmc.c gd32e50x_fwdgt.c gd32e50x_gpio.c gd32e50x_i2c.c gd32e50x_misc.c gd32e50x_pmu.c gd32e50x_rcu.c gd32e50x_rtc.c gd32e50x_sdio.c gd32e50x_shrtimer.c gd32e50x_spi.c gd32e50x_sqpi.c gd32e50x_timer.c gd32e50x_tmu.c gd32e50x_usart.c gd32e50x_wwdgt.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32E50x/Source/IAR/: startup_gd32e508.s startup_gd32e50x_cl.s startup_gd32e50x_hd.s startup_gd32e50x_xd.s startup_gd32eprt.s
